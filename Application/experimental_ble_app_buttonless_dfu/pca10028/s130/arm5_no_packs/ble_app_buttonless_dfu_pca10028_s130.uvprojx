# Keil uVision project ble_app_buttonless_dfu_pca10028_s130.uvprojx, settings and files
target nrf51422_xxac (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD NRF51422 BOARD_PCA10028 NRF_SD_BLE_API_VERSION=2 S130 NRF51 SOFTDEVICE_PRESENT NRF_DFU_SETTINGS_VERSION=1 SWI_DISABLE0
  c include: ..\..\..\config\ble_app_buttonless_dfu_pca10028_s130;..\..\..\config;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_advertising;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_dtm;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_racp;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ans_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_bas;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_bas_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_cscs;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_cts_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_dfu;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_dis;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_gls;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hids;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hrs;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_hts;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ias;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_ias_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lbs;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_lls;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_nus;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_nus_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_rscs;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\ble_services\ble_tps;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\common;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\nrf_ble_qwr;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\ble\peer_manager;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\boards;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\adc;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\clock;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\common;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\comp;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\delay;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\gpiote;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\hal;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\i2s;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\lpcomp;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\pdm;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\power;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\ppi;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\pwm;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\qdec;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\rng;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\rtc;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\saadc;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\spi_master;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\spi_slave;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\swi;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\timer;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twi_master;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\twis_slave;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\uart;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\usbd;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\drivers_nrf\wdt;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\bootloader\dfu;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\bsp;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\button;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\crc16;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\crc32;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\csense;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\csense_drv;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\experimental_section_vars;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fds;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fstorage;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\gpiote;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\hardfault;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\hci;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\led_softblink;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\log\src;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\low_power_pwm;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\mem_manager;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\pwm;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\queue;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\scheduler;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\sensorsim;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\slip;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\timer;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\twi;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\uart;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\audio;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\cdc;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\generic;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\class\msc;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\usbd\config;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\util;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\common\softdevice_handler;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s130\headers;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\softdevice\s130\headers\nrf51;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\toolchain;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\external\segger_rtt;..\config;..\..\..\..\..\nRF5_SDK_12.3.0_d7731ad\components\libraries\fifo
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF51422,-DBOARD_PCA10028,-DNRF_SD_BLE_API_VERSION=2,-DS130,-DNRF51,-DSOFTDEVICE_PRESENT,-DNRF_DFU_SETTINGS_VERSION=1,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_buttonless_dfu_pca10028_s130;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\..\components\softdevice\s130\headers\nrf51;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20002008 size 0x6058
  group Application
    ../../../: main.c nrf_dfu_flash_buttonless.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/boards/: boards.c
  group Board Support
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/ble/ble_advertising/: ble_advertising.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/ble/ble_services/ble_dfu/: ble_dfu.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_Bootloader
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/bootloader/dfu/: nrf_dfu_settings.c
  group nRF_Drivers
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/fifo/: app_fifo.c
  group nRF_Libraries
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/button/: app_button.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/scheduler/: app_scheduler.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/timer/: app_timer.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/crc16/: crc16.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/crc32/: crc32.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/fds/: fds.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/fstorage/: fstorage.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/sensorsim/: sensorsim.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/ble/ble_services/ble_nus/: ble_nus.c
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/uart/: app_uart_fifo.c
  group nRF_Log
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../nRF5_SDK_12.3.0_d7731ad/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../nRF5_SDK_12.3.0_d7731ad/components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s130_nrf51_2.0.1_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s130_nrf51_2.0.1_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_buttonless_dfu_pca10028_s130;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20001fe8 size 0x6018
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
